require flash-utility.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    https://gforge.ti.com/gf/download/frsrelease/518/4471/Flash_v1.5.1.0.zip;name=base \
    "

SRC_URI[base.md5sum] = "a90b935a95b52e60ec99b1090dd417e5"
SRC_URI[base.sha256sum] = "f4611b840aff3e2bffdfa1bd978fb7105a951b2467f6b575e9185a9a287514e5"
