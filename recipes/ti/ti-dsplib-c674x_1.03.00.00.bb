require ti-dsplib-c674x.inc

PV = "1_03_00_00"

SRC_URI[dsplibbin.md5sum] = "c80527cb453c36b3bd30fcf383fa70df"
SRC_URI[dsplibbin.sha256sum] = "c890546477e76c825510fdd54acb6be039c8a77704e6499883ab8783e85c3812"
