require ti-docs-psp.inc

PR = "r0"
PV = "03.02.00.31"

COMPATIBLE_MACHINE = "dm6467-evm"

RELNOTESTOPIC = "DaVinci_PSP_03.02_Beta_\(r31\)_Release_Notes"
USERGUIDETOPIC = "DaVinci_PSP_03.02_Linux_Installation_User_Guide"
DATASHEETTOPIC = ""
