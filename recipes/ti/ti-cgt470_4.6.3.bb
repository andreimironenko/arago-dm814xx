require ti-cgt470.inc

PE = "1"
PV = "4_6_3"
PVwithdots = "4.6.3"

SRC_URI[cgt470bin.md5sum] = "f4bc0c683a8a1832206df024dabf49f9"
SRC_URI[cgt470bin.sha256sum] = "b46ce1418c438d10b88f6b30fa5db31c00e0f58bb921cf7834c694ddcea403b3"

