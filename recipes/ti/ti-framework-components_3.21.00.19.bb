require ti-framework-components.inc

PV = "3_21_00_19"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Framework_Components/${PV}/exports/framework_components_${PV}${PVExtra},lite.tar.gz;name=fctarball"

SRC_URI[fctarball.md5sum] = "d9d5efea5c944dd4f8078451d1942d42"
SRC_URI[fctarball.sha256sum] = "12562b2336d1fbcc27c6152a3bc1dba40e1461edc58e3f5d732707867afd19ee"

