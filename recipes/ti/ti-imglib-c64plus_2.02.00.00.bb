require ti-imglib-c64plus.inc

PV = "2_02_00_00"

SRC_URI[imglibbin.md5sum] = "20fbe54ddf556bc451b722ca0216f0fb"
SRC_URI[imglibbin.sha256sum] = "4103b7fde67f1795b52c28f99acfb430b86d8189848de1e4a92e80f5d1154019"
