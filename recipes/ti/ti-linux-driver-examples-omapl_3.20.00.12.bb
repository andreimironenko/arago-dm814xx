require ti-linux-driver-examples-omapl.inc

PV = "3_20_00_12"
PV_dot = "03.20.00.12"

SRC_URI[linuxexamplestarball.md5sum] = "6630cdb98ec3f751e249d3567534299c"
SRC_URI[linuxexamplestarball.sha256sum] = "e99c481979655bd68157f5170ce708aec12884cecd458bf3dd5afc21021e9a04"
