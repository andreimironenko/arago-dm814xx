require ti-slog.inc

PV = "04_00_00_02"

SRC_URI[md5sum] = "06cabc0564b7270d6ff4100a4be023d2"
SRC_URI[sha256sum] = "d27888ce47f91ecad899459b85f5001ffddbba970dfe7a00638c1f057224f432"
