require ti-xdctools.inc

PV = "3_23_03_53"

S = "${WORKDIR}/ti/xdctools_${PV}"

SRC_URI[xdcbin.md5sum] = "e58c9d7cde2a473adf228c1305a1d91e"
SRC_URI[xdcbin.sha256sum] = "33b755670615cf8b4da6e2ae3fa9c266c202dd04dd81bfcda6c2fc9b1677636e"
