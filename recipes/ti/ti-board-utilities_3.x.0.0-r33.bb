require ti-board-utilities.inc

PV = 3.x.0.0-r33

COMPATIBLE_MACHINE = "(dm365-evm|dm355-evm|dm6467-evm)"

SRC_URI[boardutilitiestarball.md5sum] = "dcd26c59ef989916c16544467ea016aa"
SRC_URI[boardutilitiestarball.sha256sum] = "3b039cc0bd01260e71a2fb2f94404f145a8b3898964cc67a552376313162bd09"

PR = "r1"
