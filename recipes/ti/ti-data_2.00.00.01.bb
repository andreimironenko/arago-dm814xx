require ti-data.inc

PV = "2_00_00_01"

COMPATIBLE_MACHINE = "(ti816x|ti814x|ti811x)"

SRC_URI[ti816x_datatarball.md5sum] = "a1e6638921d65694ac8521457fcac592"
SRC_URI[ti816x_datatarball.sha256sum] = "ebbc361fe1540d17f78d75bd4d4b50dfd6723daa74259f30e3be46dcd9b3ec68"
