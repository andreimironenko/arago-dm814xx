require ti-dmai.inc

PV = "2_20_00_10"
PR = "r1"
 
COMPATIBLE_MACHINE = "(dm365-evm|da850-omapl138-evm|omap3evm|dm37x-evm)"

SRCREV         = "570"
DMAIBRANCH     = "tags/TAG_${PV}"

