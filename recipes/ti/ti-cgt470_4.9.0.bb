require ti-cgt470.inc

PE = "1"
PV = "4_9_0"
PVwithdots = "4.9.0"

SRC_URI[cgt470bin.md5sum] = "765ee1b06fe24921fc8543d21a82aa2a"
SRC_URI[cgt470bin.sha256sum] = "eab3b49ce4cf91732b8111c2240de943d25110870cb4c617727184045bc5dc3d"

