require ti-hdvpss-display-utils.inc

PV = "1_00_00_04"

SRC_URI[hdvpss.md5sum] = "ee7f6c85f9d62cd946ebdf2e869e930e"
SRC_URI[hdvpss.sha256sum] = "486204a0db0a0fc58358f84c0cffe1adb3945725ef25e2ad2682b214f964d386"

