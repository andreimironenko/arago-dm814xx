require ti-cgt6x.inc

PE = "1"
PV = "7_3_1"
PVwithdots = "7.3.1"

SRC_URI[cgt6xbin.md5sum] = "6ddbd726be4e4cdf5f156c9f10610aab"
SRC_URI[cgt6xbin.sha256sum] = "deff7c9fa39a3b07e01707d0d70f52a396270249b1c57451b4441c2c2de90228"
