require ti-media-controller-hdvpss-loader.inc

PV = "1_00_00_01"

SRC_URI[md5sum] = "db833c915e27dd77369d7f14050b7395"
SRC_URI[sha256sum] = "d7be7ddf6e9d31919af9c6513f2830e40c67737184f06b0e8f35dad7ebdfd0e4"
