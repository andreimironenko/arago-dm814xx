require ti-signal-analyzer-demo.inc

PV = "1_00_00_03"

SRC_URI[sademo.md5sum] = "4038dac51689ed1ad3c7b2ba4ef68227"
SRC_URI[sademo.sha256sum] = "84e264cce148df8d95029130e2ca258954663d8b469bf9804edbd92dd05f329f"

