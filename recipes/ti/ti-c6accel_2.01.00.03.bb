require ti-c6accel.inc

PV = "2_01_00_03"

SRC_URI = "https://gforge01.dal.design.ti.com/gf/download/frsrelease/475/4180/c6accel_${PV}_Linux-x86_Setup.bin;name=c6accelbin"

SRC_URI[c6accelbin.md5sum] = "0f04b7a055acf51752e87745695109e8"
SRC_URI[c6accelbin.sha256sum] = "b0a6273c99c370aa60ca06a20f655b9d184674a226486d1ef4058969b52e3cde"

