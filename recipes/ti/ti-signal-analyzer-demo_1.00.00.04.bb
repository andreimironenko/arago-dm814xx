require ti-signal-analyzer-demo.inc

PV = "1_00_00_04"

SRC_URI[sademo.md5sum] = "bea931e56caf0b19545b3e4a3d85bffe"
SRC_URI[sademo.sha256sum] = "a5d1ac702daeb9fbb9e3bdaa62481ce9714721629614b4137ff8d3996e293ea9"

