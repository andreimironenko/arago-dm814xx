require ti-docs-psp.inc

PR = "r0"
PV = "03.01.00.31"

COMPATIBLE_MACHINE = "(dm365-evm|dm355-evm)"

RELNOTESTOPIC = "DaVinci_PSP_03.01_Beta_Release_Notes"
USERGUIDETOPIC = "DaVinci_PSP_03.01_Linux_Installation_User_Guide"
DATASHEETTOPIC = ""
