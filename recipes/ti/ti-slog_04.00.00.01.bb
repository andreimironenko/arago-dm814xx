require ti-slog.inc

PV = "04_00_00_01"

SRC_URI[md5sum] = "ea684e87bd79e60278452e0ae7e66cd6"
SRC_URI[sha256sum] = "2784c764c2e0a71dd5ba11988dc0bf4af38a6745601ad028adeb3306ad2ad97f"
