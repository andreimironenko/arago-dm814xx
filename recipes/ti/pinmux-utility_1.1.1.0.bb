require pinmux-utility.inc

SRC_URI = "\
    https://gforge01.dal.design.ti.com/gf/download/frsrelease/478/4200/PinMuxUtility_v1.1.1.0.zip \
    "

SRC_URI[md5sum] = "cec13705d98c04803793e109972c3c8b"
SRC_URI[sha256sum] = "17b32f2f326546417e02cef988e9ab4063179e86a03b657e353e16c77c474486"
