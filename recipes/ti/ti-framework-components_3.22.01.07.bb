require ti-framework-components.inc

PV = "3_22_01_07"

SRC_URI[fctarball.md5sum] = "a7beb19129acc827da0c61013ef911b1"
SRC_URI[fctarball.sha256sum] = "3fb9877dc27362a9018d501d0324c377f69f6972411717004249b42134d7d180"

do_compile() {
    :
}
