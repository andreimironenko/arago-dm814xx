require ti-osal.inc

PV = "1_20_00_06_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/OSAL/1_20_00_06/exports/osal_1_20_00_06_eng.tar.gz;name=osaltarball"

SRC_URI[osaltarball.md5sum] = "b6fefd0784b2444b942961bf02e0056f"
SRC_URI[osaltarball.sha256sum] = "13cbbcc8a8dff3b265f603946456c7c996eb905a54c6883ecf2c5775d4fae4e0"
