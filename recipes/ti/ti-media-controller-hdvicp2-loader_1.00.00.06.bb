require ti-media-controller-hdvicp2-loader.inc

PV = "1_00_00_06"

SRC_URI[md5sum] = "b46125cfd59fc09f9005c284865d59be"
SRC_URI[sha256sum] = "eaa4a5799cb13bfefc4e3878054a4db34be3fdc7920bb69ca8a54d6d3ae1748e"
