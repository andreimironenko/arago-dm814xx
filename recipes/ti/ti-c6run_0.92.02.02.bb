require ti-c6run.inc

PV = "0_92_02_02"

SRC_URI = "https://gforge.ti.com/gf/download/frsrelease/376/3865/C6Run_${PV}.tar.gz;name=c6runtarball"

SRC_URI[c6runtarball.md5sum] = "f1c51441673b0681af84283dc8b97228"
SRC_URI[c6runtarball.sha256sum] = "0f30455a3af68844c3365b84daceeb5ecfd96a86ff88d10bc428f24798513df2"

