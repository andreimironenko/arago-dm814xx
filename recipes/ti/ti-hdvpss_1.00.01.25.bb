require ti-hdvpss.inc

PV = "01_00_01_25"

SRC_URI =+ "file://0001-Updates-for-OMX-5.00.00.09-Release.patch"

SRC_URI[hdvpss.md5sum] = "418b4ff58c580687c21403f8bc8b7b8c"
SRC_URI[hdvpss.sha256sum] = "632299d7819de5cbf00a2744426a8ad6e2c2a9fd99a8ab8fdf64f31b2bdc11c3"

