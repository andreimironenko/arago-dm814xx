require ti-xdais.inc

PV = "7_22_00_03"

SRC_URI[xdaistarball.md5sum] = "e090e97bfec794f1c0b1ed892e81a6c6"
SRC_URI[xdaistarball.sha256sum] = "cd3b5f16d11094f95f36ed70fbc8f8b6d14fb52e34a99466334833facd15ebc0"
