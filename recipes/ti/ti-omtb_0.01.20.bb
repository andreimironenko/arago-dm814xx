require ti-omtb.inc

PV = "00_01_20"
PVExtra = ""

SRC_URI[omtb.md5sum] = "6bcafcd90035d86d1c286c5210c13e34"
SRC_URI[omtb.sha256sum] = "d336ed1ae7cb590fd1a940d0fbe888cb95603c7d4e5f3a1d68949968236b6f63"
