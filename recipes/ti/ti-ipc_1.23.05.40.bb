require ti-ipc.inc

PV = "1_23_05_40"
PVExtra = ""

SRC_URI[ipcbin.md5sum] = "cabee71231c97f0e339a631cdb19d6ec"
SRC_URI[ipcbin.sha256sum] = "84726e92d35f5dcb491edc85125dc0d72a8720e8d1303c7a18b7a4fb69332e78"
