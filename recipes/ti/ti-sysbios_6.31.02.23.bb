require ti-sysbios.inc

PV = "6_31_02_23"

SRC_URI[sysbiosbin.md5sum] = "50f9fc8b8ae3a8d4a84c699a99e89eb3"
SRC_URI[sysbiosbin.sha256sum] = "fd6653bb47bff8df3547f03f1b6db46d48251bdabd07b6af395e31bced8bb043"

