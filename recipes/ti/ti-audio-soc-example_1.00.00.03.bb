require ti-audio-soc-example.inc

PV = "1_00_00_03"

SRC_URI[audiosoctarball.md5sum] = "1d15dea6e29a783af3ee770243039ff4"
SRC_URI[audiosoctarball.sha256sum] = "4c099a91b646df92c15272b1e221e24adf4b6ebf3a07b21a689428b89a54db86"
