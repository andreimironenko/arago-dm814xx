require ti-audio-soc-example.inc

PV = "1_00_00_01"

SRC_URI[audiosoctarball.md5sum] = "fcc2e8484ed645fbbce1b89369838b28"
SRC_URI[audiosoctarball.sha256sum] = "d804366718cfbb7538ed1a2f65573419506fccb0e5adbc6d034f40725dcca858"
