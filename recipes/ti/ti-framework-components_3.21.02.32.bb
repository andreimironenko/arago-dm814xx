require ti-framework-components.inc

PV = "3_21_02_32"
PVExtra = ""

SRC_URI[fctarball.md5sum] = "779a76732902619850eba0a80d565219"
SRC_URI[fctarball.sha256sum] = "febcfa3c9ac8f8a8b5aec360b2efa55238cf97d44817452e3ebbacaa091697de"
