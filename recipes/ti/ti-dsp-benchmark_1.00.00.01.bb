require ti-dsp-benchmark.inc

PV = "1_00_00_01"

SRC_URI[dspbenchmarksbin.md5sum] = "47f60c462e65018bea93ab1ff6e3fbf0"
SRC_URI[dspbenchmarksbin.sha256sum] = "bcd30ab06caf0d72026fbe5a55956747113476b88928229a7f6608f9dd83e24f"
