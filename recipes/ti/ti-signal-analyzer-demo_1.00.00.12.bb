require ti-signal-analyzer-demo.inc

PV = "1_00_00_12"

SRC_URI = "https://gforge.ti.com/gf/download/frsrelease/626/4922/signal-analyzer-demo_${PV}.tar.gz;name=sademo"

SRC_URI[sademo.md5sum] = "e6a6e31c57e3041aa5de8fc51ecb3552"
SRC_URI[sademo.sha256sum] = "2aa0d48b2f024fd8c8e17980ecb9123b4522b50a6e73a32b24ae315704e2c72b"
