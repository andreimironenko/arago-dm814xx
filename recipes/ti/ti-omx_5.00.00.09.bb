require ti-omx.inc

PV = "05_00_00_09"
PVExtra = ""

SRC_URI[omx.md5sum] = "d662b35d1441bf9e9a01942d09849850"
SRC_URI[omx.sha256sum] = "f29c3c1d58a88b0a3d91d3896c5004420917dad8aea2a0d85d216c3bccc9af9e"

