require ti-docs-psp.inc

PR = "r1"
PV = "03.01.00.37"

COMPATIBLE_MACHINE = "(dm365-evm|dm355-evm)"

RELNOTESTOPIC = "DaVinci_PSP_03.01_GA_\(r37\)_Release_Notes"
USERGUIDETOPIC = "DaVinci_PSP_03.01_Linux_Installation_User_Guide"
DATASHEETTOPIC = ""
