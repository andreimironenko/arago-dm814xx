require ti-ipc.inc

PV = "1_23_05_37"
PVExtra = "_eng"

SRC_URI[ipcbin.md5sum] = "9938ba02782f3dbb3c22de502efb5d7c"
SRC_URI[ipcbin.sha256sum] = "3c65418ccaab48f656ea7d4c9c0febe3998d2cc99b28c11dd92fe5cece6b8e7b"

# SRC_URI += "file://0001-Added-sdk-make-install-file-to-ipc.patch \
# "
