require ti-firmware-dm814x.inc

PV = "05_02_00_26"

SRC_URI[firmware.md5sum] = "bb1e7f0271fac9843679495d5589dcb5"
SRC_URI[firmware.sha256sum] = "038eb8496a0ae8225673a37849ae8e9b2da23394d553ee2527de19d6275f382d"
