require ti-hdvpss-display-utils.inc

PV = "1_00_00_11"

SRC_URI[hdvpss.md5sum] = "d28fcaccd256e07a1a4790e175fcf196"
SRC_URI[hdvpss.sha256sum] = "c6e45d92f74842d567974f92028a3a2a6a12ed9b65f77affbbfd70f87f87a8b1"
