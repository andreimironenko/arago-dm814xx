require ti-c6accel.inc

PV = "2_01_00_02"

SRC_URI = "https://gforge01.dal.design.ti.com/gf/download/frsrelease/471/4108/c6accel_2_01_00_02_Linux-x86_Setup.bin;name=c6accelbin"

SRC_URI[c6accelbin.md5sum] = "4c7c14b4b46512ef0c6a6f06961f6eb9"
SRC_URI[c6accelbin.sha256sum] = "8110e18310236703a5d3538b39df23e69790a22b3e33e06822c19c13ecb34165"

