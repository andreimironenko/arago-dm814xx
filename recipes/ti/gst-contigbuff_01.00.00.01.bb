require gst-contigbuff.inc

PV = "01_00_00_01"

SRC_URI[md5sum] = "593ed429597881d44554e6991bb70614"
SRC_URI[sha256sum] = "85774e8e7f9ddeee79694d32ff588f8090500545092f1b960ee99f1f58eae325"
