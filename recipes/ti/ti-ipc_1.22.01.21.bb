require ti-ipc.inc

PV = "1_22_01_21"

SRC_URI[ipcbin.md5sum] = "34e65e8dd9cf9a998770907e8896e5bf"
SRC_URI[ipcbin.sha256sum] = "13548bad3f69ff71bbc170d62f9f1fc2a06e56a7576eaa5d5030a348247e48cf"

