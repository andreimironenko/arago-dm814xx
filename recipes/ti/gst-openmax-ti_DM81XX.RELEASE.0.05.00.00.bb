require gst-openmax-ti.inc

PV = "GST_DM81XX_00_05_00_00"

SRC_URI += "file://0001-omx-Update-Makefiles-to-add-syslink-packages-to-Incl.patch \
"

SRC_URI[md5sum] = "8dbfe201c893c3b2e28ad0339a853837"
SRC_URI[sha256sum] = "093258bb97161fc9710e352929afb5dbce939dbd9eca81b05368b6701917a32d"
