require ti-hdvpss-display-utils.inc

PV = "1_00_00_10"

SRC_URI[hdvpss.md5sum] = "8975169cf1a9bd98d9a73bf364a8a3c2"
SRC_URI[hdvpss.sha256sum] = "6442210aa53dc7e84aca3c35251e9e90777ddcdeaf2b0b5371daef6efede60a9"
