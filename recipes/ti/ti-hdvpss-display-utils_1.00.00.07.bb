require ti-hdvpss-display-utils.inc

PV = "1_00_00_07"

SRC_URI[hdvpss.md5sum] = "ccf4adb2e248beebc11310e78b887b6b"
SRC_URI[hdvpss.sha256sum] = "d58416ebc07344955c5f21196bad9711e10a4b2de8aac6dc37a238330e2a787b"

