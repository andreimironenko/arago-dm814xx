require ti-media-controller-utils.inc

PV = "1_00_00_02"

DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "842edfccefba71d903cac9b550a81059"
SRC_URI[sha256sum] = "b468f9aef9cf6d317eed5d2813240ffb10702b34ec0d1a458c09e2f0ca8993f6"
