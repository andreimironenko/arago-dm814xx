require ti-xdctools.inc

PV = "3_22_04_46"

SRC_URI[xdcbin.md5sum] = "4218d98e132e12346ac14411ff4d725a"
SRC_URI[xdcbin.sha256sum] = "7d1acd1bff34f639e312e40614538e4b58a0318a4b27d11eb17bbf98b8d07677"
