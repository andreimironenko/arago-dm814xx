COMPATIBLE_MACHINE = "(omap3evm|dm37x-evm)"

PV = "3_01_00_28"
SRCREV         = "9583"
DEMOSBRANCH    = "tags/TAG_${PV}"

require ti-dvsdk-demos.inc
