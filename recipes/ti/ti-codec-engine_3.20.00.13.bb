require ti-codec-engine.inc

PV = "3_20_00_13_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Codec_Engine/3_20_00_13/exports/codec_engine_3_20_00_13_eng.tar.gz;name=cetarball"

SRC_URI[cetarball.md5sum] = "e5bcd9a51d7b617d321429c962db1173"
SRC_URI[cetarball.sha256sum] = "fc738362486f9b628e85c43cdd6324de8a6d885abcfa8ddd5956fe21a5c94510"

