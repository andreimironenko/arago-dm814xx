require ti-cgt6x.inc

PE = "1"
PV = "7_3_4"
PVwithdots = "7.3.4"

SRC_URI[cgt6xbin.md5sum] = "0245785af8df8e6c843cdf121dbf0646"
SRC_URI[cgt6xbin.sha256sum] = "137d12a6570455a8deb2b2765ec9cc7e814976e4e594a21ab5dc01b6d7c61691"

