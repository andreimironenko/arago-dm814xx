require ti-hdvpss-display-utils.inc

PV = "1_00_00_14"

SRC_URI[hdvpss.md5sum] = "22212a3f325a20748b5dd5a0cf7d4c5b"
SRC_URI[hdvpss.sha256sum] = "f423a5ffae54ce432dffd6af538523c0379f891e5a21f2217798b6c636b93c2f"
