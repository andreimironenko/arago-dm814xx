require ti-hdvpss.inc

PV = "01_00_01_24"

SRC_URI[hdvpss.md5sum] = "cc3de8a80e16d9573890f941002b6d39"
SRC_URI[hdvpss.sha256sum] = "39ea727a068ee4edaba2f3e62cf54a4fdf58845c2ae97a9117017b79b4bad59d"

