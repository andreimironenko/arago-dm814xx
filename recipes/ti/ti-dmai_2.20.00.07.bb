require ti-dmai.inc

PV = "2_20_00_07"
PR = "r0"
 
COMPATIBLE_MACHINE = "(dm365-evm|da850-omapl138-evm|omap3evm|dm37x-evm)"

SRCREV         = "556"
DMAIBRANCH     = "tags/TAG_2_20_00_07"

