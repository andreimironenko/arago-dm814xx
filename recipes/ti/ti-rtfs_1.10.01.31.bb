require ti-rtfs.inc

PV = "1_10_01_31"

SRC_URI[rtfstarball.md5sum] = "6f027df1042abc27cf49fed35eb34cae"
SRC_URI[rtfstarball.sha256sum] = "e25abfebc5b41260c7560d1001510bb91fa7f01b96d179a35fb40428acd013b3"
