require ti-hdvpss-display-utils.inc

PV = "1_00_00_12"

SRC_URI[hdvpss.md5sum] = "3037b156a0c2dab1fe4d0d7ec8d36039"
SRC_URI[hdvpss.sha256sum] = "0bf5d52866362019bc326c665414378da5360b1f71b029f2777322c5cf5b3bcf"
