require ti-dmai.inc

PV = "2_20_00_09"
PR = "r1"
 
COMPATIBLE_MACHINE = "(dm365-evm|da850-omapl138-evm|omap3evm|dm37x-evm)"

SRCREV         = "567"
DMAIBRANCH     = "tags/TAG_${PV}"

