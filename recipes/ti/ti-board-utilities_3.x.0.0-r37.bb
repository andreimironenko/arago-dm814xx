require ti-board-utilities.inc

PV = 3.x.0.0-r37

COMPATIBLE_MACHINE = "(dm365-evm|dm355-evm|dm6467-evm)"

SRC_URI[boardutilitiestarball.md5sum] = "c7302ff0d015238ab9f44f2153699871"
SRC_URI[boardutilitiestarball.sha256sum] = "d8df11e7dcf5846105ec06236de1a9e2bef11d682fc098341fa20ede78bc658c"

PR = "r1"
