require ti-docs-psp.inc

PR = "r0"
PV = "03.00.01.06"

COMPATIBLE_MACHINE = "(dm3730-am3715-evm|omap3evm)"

RELNOTESTOPIC = "AM35x-OMAP35x-PSP_${PV}_Release_Notes"
USERGUIDETOPIC = "AM35x-OMAP35x-PSP_03.00.00.05_UserGuide"
DATASHEETTOPIC = ""
