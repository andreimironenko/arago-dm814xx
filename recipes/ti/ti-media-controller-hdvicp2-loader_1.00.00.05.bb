require ti-media-controller-hdvicp2-loader.inc

PV = "1_00_00_05"

DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "96277ae135aafccfa560e2084b2a0496"
SRC_URI[sha256sum] = "00fc39e023d757d68367422a653286488e86ed228ff079584b9515cf803c953a"
