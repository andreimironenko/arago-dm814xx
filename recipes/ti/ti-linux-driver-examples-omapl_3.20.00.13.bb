require ti-linux-driver-examples-omapl.inc

PV = "psp03.20.00.13"

SRC_URI[linuxexamplestarball.md5sum] = "a9b501d40a63167f12dec6de6bc1b078"
SRC_URI[linuxexamplestarball.sha256sum] = "635d7d6f2e998f17b3736b4f4a514763fd3b83073af3a1e1c0dc33b9adbb9818"

