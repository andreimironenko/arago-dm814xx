require ti-ivahd-hdvicp20api.inc

PV = "01_00_00_19"

SRC_URI[hdvicp20.md5sum] = "1abfc1e8b310c48a282f8d0bd5677418"
SRC_URI[hdvicp20.sha256sum] = "c983217c1fb50e62abe90c9a10975c7ad26b9f4bb53cd27c99ed34a0b7f94b92"
