require ti-omtb.inc

PV = "01_00_00_01"
PVExtra = ""

SRC_URI[omtb.md5sum] = "7416372488860e9d1b03dd3bd304e074"
SRC_URI[omtb.sha256sum] = "4e2423f120b44756d863ad4e7cb7d37731ddb0a488f836805046051976037a43"
