require ti-sysbios.inc

PV = "6_30_02_35_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/BIOS/6_30_02_35/exports/bios_setuplinux_6_30_02_35_eng.bin;name=sysbiosbin"

SRC_URI[sysbiosbin.md5sum] = "6485db7a10074b213dd42eb1177a8cba"
SRC_URI[sysbiosbin.sha256sum] = "aeb68db6b12c3acf8a301bbdb4694b2ec40dcf1adb312a51a651d43fdbe09cdd"

