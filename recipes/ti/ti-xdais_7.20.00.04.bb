require ti-xdais.inc

PV = "7_20_00_04_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/XDAIS/7_20_00_04/exports/xdais_7_20_00_04_eng.tar.gz;name=xdaistarball"

SRC_URI[xdaistarball.md5sum] = "193d131018cef08d98055aac7da13508"
SRC_URI[xdaistarball.sha256sum] = "3ee86d61e467b9f177d9e63e5b930d9e9067b5e0d1c45ceca91ac761f7fe35cc"


