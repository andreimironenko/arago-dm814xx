require ti-rpe.inc

PV = "1_00_00_07"

SRC_URI = "http://swubn01.india.ti.com/publish/RPE/${PV}/exports/rpe-${PV}.tar.gz;name=rpe \
"

SRC_URI[rpe.md5sum] = "c4a092af3e0d5b07c399c03a0ae4b87c"
SRC_URI[rpe.sha256sum] = "0e529597caa2f5542552d1d41ec8b0beb878f4f172935f26a89c7e048c414b07"
