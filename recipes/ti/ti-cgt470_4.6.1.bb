require ti-cgt470.inc

PE = "1"
PV = "4_6_1"
PVwithdots = "4.6.1"

SRC_URI[cgt470bin.md5sum] = "8218f59222d884632d6095494e51d2fa"
SRC_URI[cgt470bin.sha256sum] = "7fb31079ea1301acacf960d444407c3c0e6aeaa783b9fbf765c97e268e012309"

