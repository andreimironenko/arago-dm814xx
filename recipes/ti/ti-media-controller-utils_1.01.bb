require ti-media-controller-utils.inc

SRCREV = "6"
PR = "${INC_PR}.8"
