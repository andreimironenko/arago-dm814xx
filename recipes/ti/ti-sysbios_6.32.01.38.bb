require ti-sysbios.inc

PV = "6_32_01_38"

SRC_URI[sysbiosbin.md5sum] = "7b507f2abc1a0c74f7511e61716814d3"
SRC_URI[sysbiosbin.sha256sum] = "9b278c5ea5a63f4ebf0cb3e15477d587aaa2e1f42334cc596fe77a312e0329b6"
