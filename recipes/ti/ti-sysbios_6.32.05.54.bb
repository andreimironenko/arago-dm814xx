require ti-sysbios.inc

PV = "6_32_05_54"
PVExtra = ""

SRC_URI[sysbiosbin.md5sum] = "696f1ae82a9492a4bcc9c060d113660f"
SRC_URI[sysbiosbin.sha256sum] = "44a78defc26e811472416015d035a69de8babb40693d8134a265a527767f2ba9"
