require ti-signal-analyzer-demo.inc

PV = "1_00_00_01"

SRC_URI[sademo.md5sum] = "0c98fcdb0c4d4a27c9d861cc7c57b99d"
SRC_URI[sademo.sha256sum] = "f1f5fb08d92577da912977697392ca25979358fe3313ef13239b2502bc1bd58f"

