require ti-syslink.inc

PV = "2_00_04_83"

SRC_URI += "file://0001-Added-sdk-make-install-file-to-syslink.patch \
"

SRC_URI[syslinktarball.md5sum] = "14f5d2adac8206a35b136a67f101374b"
SRC_URI[syslinktarball.sha256sum] = "6d91c51fc642a30eb16496a884372a70b9c861c09529eef303d98488b6d96c3e"
