require ti-dspbios.inc

PV = "5_41_10_36"

SRC_URI[biosbin.md5sum] = "a8df6bb97005b167fd10f4d6bd300f2f"
SRC_URI[biosbin.sha256sum] = "5a0bb31ac6fa9080e03213a7bd418e7fb161858c3983b978820861be8e69bbcb"
