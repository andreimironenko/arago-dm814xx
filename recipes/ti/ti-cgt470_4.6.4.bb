require ti-cgt470.inc

PE = "1"
PV = "4_6_4"
PVwithdots = "4.6.4"

SRC_URI[cgt470bin.md5sum] = "c507fd372672b1cbda4dad4c4534fee0"
SRC_URI[cgt470bin.sha256sum] = "fce42d122a1f137f373c3b883678eaba4bdbe4d113f2b4227bec0e41501151f9"

