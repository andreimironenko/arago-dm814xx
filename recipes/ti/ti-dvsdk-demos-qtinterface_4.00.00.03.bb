
COMPATIBLE_MACHINE = "(dm365-evm)"

PV = "4_00_00_03"
SRCREV         = "9631"
DEMOSBRANCH    = "tags/TAG_${PV}"

require ti-dvsdk-demos-qtinterface.inc
PR = "r1"

