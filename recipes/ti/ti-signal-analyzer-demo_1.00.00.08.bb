require ti-signal-analyzer-demo.inc

PV = "1_00_00_08"

SRC_URI[sademo.md5sum] = "99299141bc1b747ae616262ba4f05c6f"
SRC_URI[sademo.sha256sum] = "74dc166cdd664f115193a7e43715a35d841a2dbbcd675de717fcecb9fb1fe731"
