require ti-sysbios.inc

PV = "6_32_04_49"

SRC_URI[sysbiosbin.md5sum] = "2df32d681f33d6db1e298989695a85bf"
SRC_URI[sysbiosbin.sha256sum] = "f3cd38abf6ba0fc2d6c5c934b4c13033e8f1b48e18434d8efa2b63e16ae3722f"

