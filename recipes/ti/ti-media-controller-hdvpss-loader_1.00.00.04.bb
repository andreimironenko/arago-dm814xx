require ti-media-controller-hdvpss-loader.inc

PV = "1_00_00_04"

DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "8c2189615657f2a6df89c05acd170b95"
SRC_URI[sha256sum] = "2d0c00dfe2912bef3abd143639a4d34df4be70f98af153331ac8a0a5f9d5130e"
