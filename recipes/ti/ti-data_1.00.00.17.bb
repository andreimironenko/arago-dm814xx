require ti-data.inc

PV = "1_00_00_17"

SRC_URI[omap3530_datatarball.md5sum] = "f44568509581f53bc24b6a13073a567e"
SRC_URI[omap3530_datatarball.sha256sum] = "260cd273f73d6c1961792f9c9c8872f12cbc1dcb132792b1fdc8c007469a250c"

SRC_URI[dm365_datatarball.md5sum] = "0a771b26d6f80a4e0b20b498e5fe58ba"
SRC_URI[dm365_datatarball.sha256sum] = "d7d30154709dd13eed5f28dc914fa5beb9d90e135be1542f29e34053311a91af"

SRC_URI[omapl138_datatarball.md5sum] = "35e0ebb0f7bff58c586c9eb02bc358b0"
SRC_URI[omapl138_datatarball.sha256sum] = "ffa216dbf6586d595b214d3b36684855007129a1cca801e6188e797ba3aef2d9"

