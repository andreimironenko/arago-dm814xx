require ti-signal-analyzer-demo.inc

PV = "1_00_00_11"

SRC_URI = "https://gforge.ti.com/gf/download/frsrelease/605/4880/signal-analyzer-demo_${PV}.tar.gz;name=sademo"

SRC_URI[sademo.md5sum] = "56422067d014ce783ab903d02f9145e6"
SRC_URI[sademo.sha256sum] = "29b9941866fcc0a5fae744ac534fb70ae7c7dfad3178ac094879c6309b47b15a"
