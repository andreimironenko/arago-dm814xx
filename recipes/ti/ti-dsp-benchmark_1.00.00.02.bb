require ti-dsp-benchmark.inc

PV = "1_00_00_02"

SRC_URI[dspbenchmarksbin.md5sum] = "060d2c32c4f88390e93cdb3932b1df5f"
SRC_URI[dspbenchmarksbin.sha256sum] = "d09d6240c2e57bfb2919e97481304cce6240e23dc34765229a03bdcf083200f7"
