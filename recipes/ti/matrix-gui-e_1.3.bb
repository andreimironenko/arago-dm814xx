require matrix-gui-e.inc

SRCREV = "295"
PR = "${INC_PR}.16"

