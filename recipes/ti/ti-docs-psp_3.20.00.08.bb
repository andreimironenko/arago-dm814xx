require ti-docs-psp.inc

PR = "r0"
PV = "03.20.00.08"

COMPATIBLE_MACHINE = "(da830-omapl137-evm|da850-omapl138-evm)"

RELNOTESTOPIC = "DaVinci_PSP_${PV}_Release_Notes"
USERGUIDETOPIC = "Community_Linux_PSP_for_DA8x\/OMAP-L1\/AM1x"
DATASHEETTOPIC = "DaVinci_PSP_SDK_${PV}_Datasheet"
