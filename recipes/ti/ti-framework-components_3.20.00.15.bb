require ti-framework-components.inc

PV = "3_20_00_15_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Framework_Components/3_20_00_15/exports/framework_components_3_20_00_15_eng,lite.tar.gz;name=fctarball"

SRC_URI[fctarball.md5sum] = "80141ec9924b7c7334ca645ea49b951f"
SRC_URI[fctarball.sha256sum] = "7420d988c3f4482b265c9e77eafa3040fa92d44d8a6757d7adfc3b9f157306d6"


