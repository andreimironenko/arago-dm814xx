require ti-omtb.inc

PV = "01_00_00_02"
PVExtra = ""

SRC_URI[omtb.md5sum] = "b73ebc7ebc69cf9d88611b71b895dee9"
SRC_URI[omtb.sha256sum] = "695fd71da6691056996c801f8b8b7c400689d1470cb35bafc8254d329d82fb97"
