require ti-media-controller-hdvpss-loader.inc

PV = "1_00_00_03"

DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "4183c69f9e58e3a8bf2b2def73a0ae8e"
SRC_URI[sha256sum] = "24845adb3ea299aef668109c2cdffcbddb5698a58be129e638fbae005ce04fe2"
