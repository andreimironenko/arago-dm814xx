require ti-rpe.inc

PV = "1_00_00_04"

SRC_URI = "http://swubn01.india.ti.com/publish/RPE/${PV}/exports/rpe-${PV}.tar.gz;name=rpe \
"

SRC_URI[rpe.md5sum] = "693b0a6b79582e4709441a0c48c7f4c0"
SRC_URI[rpe.sha256sum] = "91ee42a2f13be48966b3092f39a07ef951855b6522dbbcb986a038743250f03e"
