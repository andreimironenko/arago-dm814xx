require ti-hdvpss.inc

PV = "01_00_01_28"

SRC_URI[hdvpss.md5sum] = "0e4a3f4f24d3f71b35cf7e78707dabb8"
SRC_URI[hdvpss.sha256sum] = "16e400b513ea8c27a9ca407373247672e98af57e5284ed78f5567c8ee37e2dba"
