require ti-signal-analyzer-demo.inc

PV = "1_00_00_05"

SRC_URI[sademo.md5sum] = "c5895a066c4e637218de8cc0636bfc6b"
SRC_URI[sademo.sha256sum] = "bc8a5109b2b167b39508c34091cb2407d48c956300dde6987dd3c40e33a9cf20"

