require ti-hdvpss-display-utils.inc

PV = "1_00_00_09"

SRC_URI[hdvpss.md5sum] = "b29cd0ecfebbfc4b61329ec1d981fa55"
SRC_URI[hdvpss.sha256sum] = "c600f31c1d6bfaf023fee0682f30d2964eae1a4f91422c909620acb77268bb35"

