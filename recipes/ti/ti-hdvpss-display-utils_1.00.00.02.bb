require ti-hdvpss-display-utils.inc

PR = "1"

PV = "1_00_00_02"

SRC_URI[hdvpss.md5sum] = "019b4d0311bc965c437761b203071e31"
SRC_URI[hdvpss.sha256sum] = "e4e7b60832d50eaa22e898d34605eb02d64eff4d5472a087275ed3a59bec71e1"

