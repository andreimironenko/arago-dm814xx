require ti-data.inc

PV = "1_00_00_18"

SRC_URI[omap3530_datatarball.md5sum] = "310025f4a62b09aa1115e00ab016e944"
SRC_URI[omap3530_datatarball.sha256sum] = "ed7a88dbc570d34a82a50287cece37833e1f0ee416f986425cffbeaacb439f6a"

SRC_URI[dm365_datatarball.md5sum] = "b8c5622cc89c7ce36c02dd1ee764ee88"
SRC_URI[dm365_datatarball.sha256sum] = "c6bed3ce8f24a419f95191661c230074c4c951b8cae3799c218f56fbc54b5939"

SRC_URI[omapl138_datatarball.md5sum] = "6c9bb856b8b27421651c0e8612b7ef09"
SRC_URI[omapl138_datatarball.sha256sum] = "c4de1ed73d7869fb1692c23f2346b7aae13ec7b9dddfc249925ae30c51ed4fc4"

