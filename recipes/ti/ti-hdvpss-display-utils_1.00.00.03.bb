require ti-hdvpss-display-utils.inc

PR = "1"

PV = "1_00_00_03"

SRC_URI[hdvpss.md5sum] = "4026e20febffd75ebdfe112e1bb7bae6"
SRC_URI[hdvpss.sha256sum] = "cf093b227fce1a41ee5c70e196f2a85c628ee1d96d1d8ed462843ecd882c2929"

