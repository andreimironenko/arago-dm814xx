require gst-openmax-ti.inc

PV = "GST_DM81XX_00_04_00_00"

SRC_URI += "file://0001-omx-Update-Makefiles-to-add-syslink-packages-to-Incl.patch \
"

SRC_URI[md5sum] = "c6ffa71d81188cd8880640f3550abb38"
SRC_URI[sha256sum] = "07ca5e53c08ae67f1b2db0c01ad584ae61d3eadba38d261eee165cae43950efa"
