require ti-framework-components.inc

PV = "3_21_00_03"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Framework_Components/${PV}/exports/framework_components_${PV}${PVExtra},lite.tar.gz;name=fctarball"

SRC_URI[fctarball.md5sum] = "a2d8fb7e0a638a69ea8f7f8f19227c01"
SRC_URI[fctarball.sha256sum] = "61463ed8eb57db72ded8b3681c450c2d47ec8304b30c3593ea09ee5e6fd4a8f4"


