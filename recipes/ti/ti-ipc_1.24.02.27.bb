require ti-ipc.inc

PV = "1_24_02_27"

SRC_URI[ipcbin.md5sum] = "31e7f4fa15e8e3f8e105eb9719b7ad95"
SRC_URI[ipcbin.sha256sum] = "509b640552e4577109da61648845d5781696289edfe76254a6606185e4953ba7"
