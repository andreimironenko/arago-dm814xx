require ti-xdais.inc

PV = "7_20_00_01_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/XDAIS/7_20_00_01/exports/xdais_7_20_00_01_eng.tar.gz;name=xdaistarball"

SRC_URI[xdaistarball.md5sum] = "b0d2d399a2c37700e0843f3289bfaa49"
SRC_URI[xdaistarball.sha256sum] = "141fbf70dc7b393ab74e3aa49ba4da0c1d7bd7b65a175423b3388cc57f74b742"


