require ti-cgt6x.inc

PE = "1"
PV = "7_2_6"
PVwithdots = "7.2.6"

SRC_URI[cgt6xbin.md5sum] = "2a818e250a572a129b9834ff9e7e345b"
SRC_URI[cgt6xbin.sha256sum] = "442a14a55030173948274f02c3cb8a5560db0af171012fbc177484da00ec4fa7"

