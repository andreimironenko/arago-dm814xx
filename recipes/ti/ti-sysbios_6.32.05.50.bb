require ti-sysbios.inc

PV = "6_32_05_50"
PVExtra = "_eng"

SRC_URI[sysbiosbin.md5sum] = "8ea37253c05423033c953468d738b9c7"
SRC_URI[sysbiosbin.sha256sum] = "399d1745ba64dc810f415bd13cde3fddb24a740db6cd22a87a160a833e4b1ecf"
