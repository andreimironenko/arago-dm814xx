require ti-signal-analyzer-demo.inc

PV = "1_00_00_09"

SRC_URI[sademo.md5sum] = "dd36332b5812a4c13f661777ebd70ce5"
SRC_URI[sademo.sha256sum] = "7ca76233ca8007b7563baea0043d0b556b9c9121399b772b91cf5dbd14136f73"
