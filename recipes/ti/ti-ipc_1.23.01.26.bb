require ti-ipc.inc

PV = "1_23_01_26"

SRC_URI[ipcbin.md5sum] = "c2e434eb9ec0f59fd36718296a4d34a9"
SRC_URI[ipcbin.sha256sum] = "56c03ef1c0051ebe38da7b752a9a396b6191c75aaa0e90157eb06293a7f27efd"
