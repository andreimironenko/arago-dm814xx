require gst-openmax-ti.inc

PV = "GST_DM81XX_00_06_00_00"

SRC_URI += "file://0001-omx-Update-Makefiles-to-add-syslink-packages-to-Incl.patch \
"

SRC_URI[md5sum] = "860e5484529e53af5d45790645f36870"
SRC_URI[sha256sum] = "b3d2e5bb4fecce626ac2f20ae583b0f480d4fe92cfb4717a9a54a80c62bcf372"
