require ti-ivahd-hdvicp20api.inc

PV = "01_00_00_18"

SRC_URI[hdvicp20.md5sum] = "87aead7c4e87d6540f2a06020e6d0cf3"
SRC_URI[hdvicp20.sha256sum] = "5244ab77be6a99d2d7398c5541b6c9390cde7cda05918e6b907b3f0d4bb74c70"
