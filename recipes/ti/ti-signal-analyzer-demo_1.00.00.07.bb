require ti-signal-analyzer-demo.inc

PV = "1_00_00_07"

SRC_URI[sademo.md5sum] = "950e0fca22259c740c98b5cacb45b857"
SRC_URI[sademo.sha256sum] = "420ae8bd4b19b773c251de8a1629342b75b72c3d1e718ebeedc54565ad0e104f"
