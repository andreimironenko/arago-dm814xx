require ti-dmai.inc

PV = "2_10_00_11"
PR = "r5"
 
COMPATIBLE_MACHINE = "(dm365-evm|dm355-evm|dm6467-evm)"

SRCREV         = "463"
DMAIBRANCH     = "branches/GITPSP_INT_101009"

