require ti-signal-analyzer-demo.inc

PV = "1_00_00_10"

SRC_URI = "https://gforge.ti.com/gf/download/frsrelease/584/4843/signal-analyzer-demo_${PV}.tar.gz;name=sademo"

SRC_URI[sademo.md5sum] = "e7dd7a735bdd34ba08d93ef785cd1a6e"
SRC_URI[sademo.sha256sum] = "d2a5f469352c50e45de40dfef40a7a1cb62db0e50807b5f20666c5fb2e8fb0b1"
