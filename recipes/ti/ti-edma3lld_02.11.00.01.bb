require ti-edma3lld.inc

PV = "02_11_00_01"

SRC_URI[edma3lldbin.md5sum] = "74ca121ba78ac30feb11b4619ecb882c"
SRC_URI[edma3lldbin.sha256sum] = "d2a464e8fcc6c632ba40b82f54dfb76badd16e65490b357d229d328b40a0fce6"

