require ti-codec-engine.inc

PV = "3_22_01_06"

SRC_URI[cetarball.md5sum] = "3087f22e05365aba684beba72c2188f3"
SRC_URI[cetarball.sha256sum] = "8febd32b1811fa4050f2cb0b4d1a4c2c08f06eb98a799771480aaa951db5db9e"
