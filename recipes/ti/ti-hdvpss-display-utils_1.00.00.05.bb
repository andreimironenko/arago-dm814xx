require ti-hdvpss-display-utils.inc

PV = "1_00_00_05"

SRC_URI[hdvpss.md5sum] = "24216283472fbe138272c317a8ad4cf6"
SRC_URI[hdvpss.sha256sum] = "db8bbdaf4339f7f9ae254c62994daed916d2c2014504cec95f8cfa8415dd8f69"

