require ti-xdctools.inc

PV = "3_23_01_43"

S = "${WORKDIR}/ti/xdctools_${PV}"

SRC_URI[xdcbin.md5sum] = "d46be4278be05128c2e6ce67c450c236"
SRC_URI[xdcbin.sha256sum] = "42f3b83172e9e9202f5f51717cc0a021c7a4069e9a0d79837ed2413a53b6d348"
