require ti-xdais.inc

PV = "7_20_00_06"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/XDAIS/${PV}/exports/xdais_${PV}${PVExtra}.tar.gz;name=xdaistarball"

SRC_URI[xdaistarball.md5sum] = "6db01e275badfb1e76111b367a14f8e8"
SRC_URI[xdaistarball.sha256sum] = "fe08159288a1748529862836a2008a94c1c5797ffe8826a8e3819f4687824f5c"


