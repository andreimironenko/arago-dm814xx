require ti-codec-engine.inc

PV = "3_21_00_10"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Codec_Engine/${PV}/exports/codec_engine_${PV}${PVExtra},lite.tar.gz;name=cetarball"

SRC_URI[cetarball.md5sum] = "16aa8c6616349f3915b8154ecef4cc7d"
SRC_URI[cetarball.sha256sum] = "a6aff625246eee07b2dcd1a0bc07f703f9f3cc794f01907567768095b665153b"


