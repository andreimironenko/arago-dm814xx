require ti-dvtb.inc

PV = "4_20_04_2"

SRC_URI[dvtbtarball.md5sum] = "0928b8ee9c99363d0bf0cb9b84c26662"
SRC_URI[dvtbtarball.sha256sum] = "934a957219376f8ef2a736f617e016abfedf14d2c1664705150264a0892c5ad0"
