require ti-osal.inc

PV = "1_20_00_08_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/OSAL/1_20_00_08/exports/osal_1_20_00_08_eng.tar.gz;name=osaltarball"

SRC_URI[osaltarball.md5sum] = "651795f7272ee9e679c6584fd9af4d03"
SRC_URI[osaltarball.sha256sum] = "49407170f52e67cd7bab6df31effce2cc64f88c84f6d9297534cb16718c98d55"
