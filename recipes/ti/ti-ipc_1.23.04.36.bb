require ti-ipc.inc

PV = "1_23_04_36"

SRC_URI[ipcbin.md5sum] = "fc096840e49774b4d2b66f4138084dc6"
SRC_URI[ipcbin.sha256sum] = "d6aa164f4edfc1611a9db56aef942e30911149a850be5822d9829a1f63a64db9"

