require ti-linuxutils.inc

PV = "3_21_00_01"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Linux_Utils/${PV}/exports/linuxutils_${PV}${PVExtra}.tar.gz"

SRC_URI[md5sum] = "62e02fe284a02032a71b8a4add08778d"
SRC_URI[sha256sum] = "91ea9ef927f9694b5d03554f71b372c35f04d644d36b69cab09db7322e4ab572"

