require ti-hdvpss-display-utils.inc

PV = "1_00_00_01"

SRC_URI[hdvpss.md5sum] = "3922c6beaf3486153251a6cf025c2db2"
SRC_URI[hdvpss.sha256sum] = "2137324c378b1042926ef3671b6809aa0d55bc627d66126e183d201007a2234f"

