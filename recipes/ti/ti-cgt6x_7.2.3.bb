require ti-cgt6x.inc

PE = "1"
PV = "7_2_3"
PVwithdots = "7.2.3"

SRC_URI[cgt6xbin.md5sum] = "2e5bf0c10645d84f7f175817d3aa2bef"
SRC_URI[cgt6xbin.sha256sum] = "2fef91507d0a6764b229a5e825a2979b0d51c76090975315cc6d6a0262d30125"
