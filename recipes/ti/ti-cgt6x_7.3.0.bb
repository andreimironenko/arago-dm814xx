require ti-cgt6x.inc

PE = "1"
PV = "7_3_0"
PVwithdots = "7.3.0"

SRC_URI[cgt6xbin.md5sum] = "9f00ed3bae17d96657347f8695d731a2"
SRC_URI[cgt6xbin.sha256sum] = "84a338be696a7a03d86e4cdf2f9af2be3c369a63c0ac1faa34eacce2f83cde23"
