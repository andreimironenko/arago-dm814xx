require ti-xdais.inc

PV = "7_21_01_07"
PVExtra = ""

SRC_URI[xdaistarball.md5sum] = "4fdf15a05f3573bca74dfa8c12134d52"
SRC_URI[xdaistarball.sha256sum] = "4b7085d82f2937854e6e402648649381e6a975baea0b7406b305583bd5c2afee"
