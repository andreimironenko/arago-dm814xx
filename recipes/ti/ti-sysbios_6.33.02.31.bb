require ti-sysbios.inc

PV = "6_33_02_31"

SRC_URI[sysbiosbin.md5sum] = "7be136ccc39394b84a72f717c1fe9da6"
SRC_URI[sysbiosbin.sha256sum] = "945be178c7495b0ba56af53fd76ea9d8e4dc647793511637d452dbd3df9954d4"
