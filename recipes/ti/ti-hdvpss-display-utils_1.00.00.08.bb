require ti-hdvpss-display-utils.inc

PV = "1_00_00_08"

SRC_URI[hdvpss.md5sum] = "aadfa1630fe963214993b7a2816d6fe1"
SRC_URI[hdvpss.sha256sum] = "a8043d7ea7328b222257c66bc37c9f6b98dac99a37da917069e9ae0c955c3a14"

