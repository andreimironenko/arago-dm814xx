require ti-media-controller-hdvpss-loader.inc

SRCREV = "6"
PR = "${INC_PR}.8"
