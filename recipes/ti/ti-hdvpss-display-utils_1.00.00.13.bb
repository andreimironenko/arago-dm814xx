require ti-hdvpss-display-utils.inc

PV = "1_00_00_13"

SRC_URI[hdvpss.md5sum] = "e032c910f949ba8ffaee20eb596909d8"
SRC_URI[hdvpss.sha256sum] = "6e234029e0688f2fe802e448a12680cea6cab92402f58bd172e1ccfb3970bcea"
