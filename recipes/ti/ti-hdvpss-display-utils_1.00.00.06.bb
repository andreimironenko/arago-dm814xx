require ti-hdvpss-display-utils.inc

PV = "1_00_00_06"

SRC_URI[hdvpss.md5sum] = "2d114d1bb5ede131c273ffdcfea108eb"
SRC_URI[hdvpss.sha256sum] = "218277ea85e85baac0a1036ede974bd9f4fafb8ffa8bc6155b3780ec6a79cf16"

