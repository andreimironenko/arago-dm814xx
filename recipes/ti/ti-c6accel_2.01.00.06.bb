require ti-c6accel.inc

PV = "2_01_00_06"

SRC_URI = "https://gforge01.dal.design.ti.com/gf/download/frsrelease/532/4570/c6accel_${PV}_Linux-x86_Setup.bin;name=c6accelbin"

SRC_URI[c6accelbin.md5sum] = "520850d8a9080f45bda5c09c414cac23"
SRC_URI[c6accelbin.sha256sum] = "a8b02460f0fdc7b206b2ba7b12c44ab8bf501c6a1754bc598939b9079c64e2e5"
