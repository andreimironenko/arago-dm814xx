require ti-c6accel.inc

PV = "1_00_00_04"

SRC_URI[c6accelbin.md5sum] = "520a2e416c6eaefb3aefcf66f775f4c7"
SRC_URI[c6accelbin.sha256sum] = "54f42307dd9122c59d0ea604ec126ba7a72dbb9772a6d845960fa8529706a400"

