require ti-media-controller-hdvicp2-loader.inc

SRCREV = "6"
PR = "${INC_PR}.8"
