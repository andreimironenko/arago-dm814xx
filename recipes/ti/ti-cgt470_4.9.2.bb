require ti-cgt470.inc

PE = "1"
PV = "4_9_2"
PVwithdots = "4.9.2"

SRC_URI[cgt470bin.md5sum] = "8c95b2795d6aa9e2ae494f1be9ce079b"
SRC_URI[cgt470bin.sha256sum] = "d754ad613b17a514e982d774dc1fcbddc38338218676d51e5431b849a6bc75fd"
