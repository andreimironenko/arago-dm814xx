require ti-framework-components.inc

PV = "2_25_02_06"

# Full-FC
#SRC_URI[cetarball.md5sum] = "729ede0fd24210d3c5439511fa859d51"
#SRC_URI[cetarball.sha256sum] = "81f815159f3dfda0525be6da543644b02c3610bcb080df170cbd27e2d8420ba2"

# Lite-FC
SRC_URI[fctarball.md5sum] = "0ff9fc152633f6bfbe7ae98902833477"
SRC_URI[fctarball.sha256sum] = "1dc2994b867c76a474fd0c7c82c544d9163f661434ce994542bba9dd2997da6a"

