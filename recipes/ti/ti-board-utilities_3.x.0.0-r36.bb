require ti-board-utilities.inc

PV = 3.x.0.0-r36

COMPATIBLE_MACHINE = "(dm365-evm|dm355-evm|dm6467-evm)"

SRC_URI[boardutilitiestarball.md5sum] = "0fd870ed1b611bffb43c735b7baad4e2"
SRC_URI[boardutilitiestarball.sha256sum] = "c9aa1d68e1b7804dfe54bbe6c5e0023bcff3e0ef6c4ba98bcec30d369b68a616"

PR = "r1"
