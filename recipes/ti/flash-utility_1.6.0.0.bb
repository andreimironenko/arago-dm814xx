require flash-utility.inc

PR = "${INC_PR}.0"

SRC_URI = "\
    https://gforge.ti.com/gf/download/frsrelease/580/4785/Flash_v1.6.0.0.zip;name=base \
    "

SRC_URI[base.md5sum] = "1f53efa31996afb5af78930739090ae6"
SRC_URI[base.sha256sum] = "f6722422016ec4e49b8c55c38affea4c924b6636a47d0d67e6537e7dab108a1b"
