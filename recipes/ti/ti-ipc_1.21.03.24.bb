require ti-ipc.inc

PV = "1_21_03_24_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/IPC/1_21_03_24/exports//ipc_setuplinux_1_21_03_24_eng.bin;name=ipcbin"

SRC_URI[ipcbin.md5sum] = "a9c1e799370dea720243eb9af9d8f3a4"
SRC_URI[ipcbin.sha256sum] = "2e9f29134361cd4b35121d34d0a787d90fe2cc1f1dd29bce8d1c5785e34dcecf"
