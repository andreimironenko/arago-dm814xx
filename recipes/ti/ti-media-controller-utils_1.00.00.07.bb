require ti-media-controller-utils.inc

PV = "1_00_00_07"

SRC_URI[md5sum] = "2bffeaf2e68344714be44af3ef3d76eb"
SRC_URI[sha256sum] = "7d3f4677efbc7b9ae89249b1b372f616899822df21af64554d57f29ca55e3a62"
