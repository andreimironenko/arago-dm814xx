require ti-ipc.inc

PV = "1_21_02_17_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/IPC/1_21_02_17/exports//ipc_setuplinux_1_21_02_17_eng.bin;name=ipcbin"

SRC_URI[ipcbin.md5sum] = "a561474b675c8b2f2a63a81e22b64f9e"
SRC_URI[ipcbin.sha256sum] = "37e1a853a1a63971df679e099d1ac03d008c0da15a043f9b69661eab037673dc"
