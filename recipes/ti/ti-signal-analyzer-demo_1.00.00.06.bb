require ti-signal-analyzer-demo.inc

PV = "1_00_00_06"

SRC_URI[sademo.md5sum] = "9f6b71102d935688d5aab2388139803b"
SRC_URI[sademo.sha256sum] = "9b7507df8820895280ae5dac58957d8ed432cffd6290dba151386beb508873a4"

