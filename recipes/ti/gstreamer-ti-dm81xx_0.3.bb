require gstreamer-ti-dm81xx.inc

PV = "TAG_DM81XX_RELEASE_0_03"
SRCREV = "985"
