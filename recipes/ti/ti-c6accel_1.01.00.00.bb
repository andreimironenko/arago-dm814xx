require ti-c6accel.inc

PV = "1_01_00_00"

SRC_URI[c6accelbin.md5sum] = "79e7ba09d2f6e50ef49ffb92527f66e4"
SRC_URI[c6accelbin.sha256sum] = "52c30aa69f6b71e8a7bdd92254fcc74665ce3a9b4e37e0adff5afcdac68a833e"

