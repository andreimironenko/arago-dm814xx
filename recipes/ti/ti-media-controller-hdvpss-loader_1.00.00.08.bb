require ti-media-controller-hdvpss-loader.inc

SRCREV = "10"
PR = "${INC_PR}.8"
