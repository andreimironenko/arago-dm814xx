require ti-c6accel.inc

PV = "1_00_00_03"

SRC_URI[c6accelbin.md5sum] = "4470543140909c2bf636ac0d93f1bd71"
SRC_URI[c6accelbin.sha256sum] = "7bcb685f96751eeb342164a1cf59424ed84c2413186619d0caacdacebef4ca1b"

