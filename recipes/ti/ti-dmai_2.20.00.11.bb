require ti-dmai.inc

PV = "2_20_00_11"
PR = "r1"
 
COMPATIBLE_MACHINE = "(dm365|omapl138|omap3)"

SRCREV         = "583"
DMAIBRANCH     = "trunk"

