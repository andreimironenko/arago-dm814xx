require ti-data.inc

PV = "1_00_00_14"

SRC_URI[dm365_datatarball.md5sum] = "6f6bb1f81745d2ca3907f90aa57a6127"
SRC_URI[dm365_datatarball.sha256sum] = "9f5bf176eb7f349ff815e20ea387538d73210791619801482789a8fcf4a45c88"

SRC_URI[dm355_datatarball.md5sum] = "924729371fe23a7358c70ba4da8ee3e4"
SRC_URI[dm355_datatarball.sha256sum] = "3d681dee9f5fac7b7f1f1c70309f929eb021f73e13f2c28d36173f3e0abfb0ac"

SRC_URI[dm6467_datatarball.md5sum] = "a598c4825125795878c4cd6ba41d95b8"
SRC_URI[dm6467_datatarball.sha256sum] = "af54ed42ba186c3fce46cb78e9b4461e894c8d35139d25e54784d3833695d49f"

