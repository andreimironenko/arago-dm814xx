
COMPATIBLE_MACHINE = "(dm365-evm)"

PV = "4_00_00_06"
SRCREV         = "9649"
DEMOSBRANCH    = "tags/TAG_${PV}"

require ti-dvsdk-demos-qtinterface.inc
PR = "r1"

