require ti-media-controller-utils.inc

PV = "2_05_00_17"

SRC_URI = "https://gforge.ti.com/gf/download/frsrelease/851/5563/media-controller-utils_${PV}.tar.gz"

S = "${WORKDIR}/media-controller-utils_${PV}"

SRC_URI[md5sum] = "1aa821602b5c9d0e58a1c5858082a3d5"
SRC_URI[sha256sum] = "42fb8c547d6487121c82b0ca17f227056b7e0441a8496bbdf85c43c52be88a0e"
