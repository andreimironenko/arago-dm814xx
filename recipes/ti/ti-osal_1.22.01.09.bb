require ti-osal.inc

PV = "1_22_01_09"

SRC_URI += "file://0001-Added-sdk-make-install-file-to-osal.patch \
"

SRC_URI[osaltarball.md5sum] = "4a41af29164b99c51601baf4382c3b98"
SRC_URI[osaltarball.sha256sum] = "c24b03974cfe3c3f5e8f9e1caf4f165761984a2915a77e766c5ea67d1a3e2b79"
