require ti-mathlib-c67x.inc

PV = "2_01_00_00"

SRC_URI[mathlibbin.md5sum] = "8b0f1c0328306f278af475964838b21e"
SRC_URI[mathlibbin.sha256sum] = "7a70c51b2cb8c6d269e9a63d6ba5ca7fd443c0cda2b734c2c37f5429c1ef337d"
