require ti-c6accel.inc

PV = "2_01_00_08"

SRC_URI = "https://gforge01.dal.design.ti.com/gf/download/frsrelease/540/4656/c6accel_${PV}_Linux-x86_Setup.bin;name=c6accelbin"

SRC_URI[c6accelbin.md5sum] = "7cdb50147e9c7e92b04a3286dd85e902"
SRC_URI[c6accelbin.sha256sum] = "f1686ea2c611a4b2401a5b6dd1dcab5d3a5ca34a69b25629c1e1ec59c03ee166"
