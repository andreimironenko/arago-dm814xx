require ti-xdais.inc

PV = "7_21_00_00"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/XDAIS/${PV}/exports/xdais_${PV}${PVExtra}.tar.gz;name=xdaistarball"

SRC_URI[xdaistarball.md5sum] = "243b32b1b7414331eb8eeb14eed4713f"
SRC_URI[xdaistarball.sha256sum] = "8311b739cf578e6c9dacc2a6afaa593b4a6659ea22f6f3a1faa668bd240ca055"


