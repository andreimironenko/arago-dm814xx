require ti-xdctools.inc

PV = "3_22_03_41"

SRC_URI[xdcbin.md5sum] = "58a50c8cd0317ed61b6fab4b2d98f2ee"
SRC_URI[xdcbin.sha256sum] = "ae8e7bbc94ec9ed4b69c68376b3857d7fc92c88ebb27bf751cbc3b6c57204a83"

