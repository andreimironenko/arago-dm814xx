require ti-dsp-benchmark.inc

PV = "1_00_00_05"

SRC_URI = "https://gforge01.dal.design.ti.com/gf/download/frsrelease/564/4836/dsp_benchmark_demo_1_00_00_05_Linux-x86_Setup.bin;name=dspbenchmarksbin"

SRC_URI[dspbenchmarksbin.md5sum] = "af22de0bfd9e6308e271224d22fd1540"
SRC_URI[dspbenchmarksbin.sha256sum] = "7ca7902e5e389ec232eeb38e9b5c3ba17b1cf84557aad709b93f8509d71e7ea4"
