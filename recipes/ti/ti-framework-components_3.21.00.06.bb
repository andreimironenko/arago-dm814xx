require ti-framework-components.inc

PV = "3_21_00_06"
PVExtra = "_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/Framework_Components/${PV}/exports/framework_components_${PV}${PVExtra},lite.tar.gz;name=fctarball"

SRC_URI[fctarball.md5sum] = "89cc5c44680965acc9c723a37566bf95"
SRC_URI[fctarball.sha256sum] = "0a62daae35953936cc55976e2612327c46c141e80f6dc45cf35f593eaadb49c9"


