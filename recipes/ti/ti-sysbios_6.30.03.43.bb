require ti-sysbios.inc

PV = "6_30_03_43_eng"

SRC_URI = "http://www.sanb.design.ti.com/tisb_releases/BIOS/6_30_03_43/exports/bios_setuplinux_6_30_03_43_eng.bin;name=sysbiosbin"

SRC_URI[sysbiosbin.md5sum] = "ca4e48f26c7e5a9e1f2405a581ce9d25"
SRC_URI[sysbiosbin.sha256sum] = "0866899cb3e42c323d40a55030236f840dacb372aa6f3b44cfa874ee3b0e8530"

