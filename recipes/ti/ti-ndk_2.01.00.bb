require ti-ndk.inc

PV = "2_01_00"
PV_short = "2_1_0"

SRC_URI[ndktarball.md5sum] = "c8166f7df16dc5518b7e7b7875a37f1b"
SRC_URI[ndktarball.sha256sum] = "bd9759ecde4c21a6cb84a58356effd1c28d5b3a0b446bee1871d4c21a1cdd5f5"
