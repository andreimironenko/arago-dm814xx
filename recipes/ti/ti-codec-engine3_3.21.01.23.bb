require ti-codec-engine3.inc

PV = "3_21_01_23"
PVExtra = ""

SRC_URI[cetarball.md5sum] = "48321f0c82713b1388d1663ed515da77"
SRC_URI[cetarball.sha256sum] = "a796ba63fc55377860c75eaba0dc65165dbc50f371ec04702f634fb9ba7091d6"
