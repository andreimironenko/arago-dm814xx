require ti-ipc.inc

PV = "1_24_03_32"

SRC_URI[ipcbin.md5sum] = "773f87f7b5b7f524fe52538e5766c1ad"
SRC_URI[ipcbin.sha256sum] = "2d47278402fce31cf7536204b2f212a949b1463cee9bd3560e14fcaa8ead963a"

