require ti-xdctools.inc

PV = "3_20_07_86"

SRC_URI[xdcbin.md5sum] = "3cf5a9f03387ed31d97e29ac4e0e179e"
SRC_URI[xdcbin.sha256sum] = "9fc418f3dab320f27db402840fbdb57ebcbee366b5ecaef078079115c0ef3178"

