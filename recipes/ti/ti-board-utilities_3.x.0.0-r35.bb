require ti-board-utilities.inc

PV = 3.x.0.0-r35

SRC_URI[boardutilitiestarball.md5sum] = "47f189ea86f13e0f72ac2bcca6d93798"
SRC_URI[boardutilitiestarball.sha256sum] = "23d26f3eaa1719f409f2350b5415894f20ab75847a822edfb416c38d8baa4247"

PR = "r2"
