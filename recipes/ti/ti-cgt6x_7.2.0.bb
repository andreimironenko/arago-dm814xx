require ti-cgt6x.inc

PE = "1"
PV = "7_1_99+7_2_0A10232"
PVwithdots = "7.2.0A10232"

SRC_URI[cgt6xbin.md5sum] = "2050337d0911a57f9a6d34c2390da69c"
SRC_URI[cgt6xbin.sha256sum] = "44e2f14efc80375487b7a2e7cd451b6c07523899fe7560d908f290967ffafb66"

