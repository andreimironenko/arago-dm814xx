require ti-media-controller-utils.inc

SRCREV = "10"
PR = "${INC_PR}.8"
