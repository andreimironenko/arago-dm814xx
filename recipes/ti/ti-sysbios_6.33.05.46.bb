require ti-sysbios.inc

PV = "6_33_05_46"

SRC_URI[sysbiosbin.md5sum] = "a5b9f66e0baa1c54c0bc94bc5902050e"
SRC_URI[sysbiosbin.sha256sum] = "302bcfe0b5b8a8fce8cf675b104c48c1408c27b0291324543922ecbb27040116"
