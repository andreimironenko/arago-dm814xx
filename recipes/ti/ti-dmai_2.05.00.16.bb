require ti-dmai.inc

PV = "2_05_00_16"
PR = "r3"
 
COMPATIBLE_MACHINE = "(omap3evm|dm37x-evm)"

SRCREV         = "524"
DMAIBRANCH     = "tags/TAG_${PV}"

