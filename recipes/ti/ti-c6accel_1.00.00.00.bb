require ti-c6accel.inc

PV = "1_00_00_00"

SRC_URI = "https://gforge01.dal.design.ti.com/gf/download/frsrelease/397/3607/c6accel_${PV}.zip;name=c6accelzip"

SRC_URI[c6accelzip.md5sum] = "d56f909d0d3ca76295e4b17ee2dca2bc"
SRC_URI[c6accelzip.sha256sum] = "095273a1689f14ad96ca2f217dc2bff55e0b2caa2e28829abe6cd8cca75b4679"
