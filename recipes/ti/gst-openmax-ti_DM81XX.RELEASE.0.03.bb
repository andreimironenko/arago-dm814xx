require gst-openmax-ti.inc

PV = "DM81XX_RELEASE_0_03"

SRC_URI[md5sum] = "07fcd76ad9c9704b134de6c623b7a40c"
SRC_URI[sha256sum] = "715d86dd562ba007620ca10a524f87b269ddc96674ddf30e7bd9b75442db7251"
