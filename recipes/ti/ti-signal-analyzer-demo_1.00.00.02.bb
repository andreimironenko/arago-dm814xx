require ti-signal-analyzer-demo.inc

PV = "1_00_00_02"

SRC_URI[sademo.md5sum] = "6e7ece35d2293923334d582cfa123c46"
SRC_URI[sademo.sha256sum] = "513e15a42a2e6290807882aec26e7ba9cc2edd981f19fce3a8769567409155b0"

