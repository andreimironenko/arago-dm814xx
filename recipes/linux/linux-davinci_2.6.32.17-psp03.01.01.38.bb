require linux-davinci.inc

SRCREV = "0e6c031f61120e651471ad2c6d3fb82884f9aae6"

KVER = "2.6.32.17"
PSPREL = "03.01.01.38"

