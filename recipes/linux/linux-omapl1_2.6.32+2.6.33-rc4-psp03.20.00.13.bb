require linux-omapl1.inc

KVER = "2.6.33-rc4"
PSPREL = "03.20.00.13"

SRCREV = "v2.6.33-rc4_DAVINCIPSP_03.20.00.13"
