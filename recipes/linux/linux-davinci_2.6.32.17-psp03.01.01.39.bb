require linux-davinci.inc

SRCREV = "DEV.DaVinciPSP.03.01.01.39"

KVER = "2.6.32.17"
PSPREL = "03.01.01.39"
