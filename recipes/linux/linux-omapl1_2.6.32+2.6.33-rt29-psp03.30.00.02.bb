require linux-omapl1.inc

COMPATIBLE_MACHINE = "am181x-evm"

KVER = "2.6.33-rt29"
PSPREL = "03.30.00.02"

BRANCH = "v2.6.33-rt"

SRCREV = "v2.6.33.7-rt29_DAVINCIPSP_03.30.00.02"
