require linux-omap3.inc

KVER = "2.6.37"
PSPREL = "04.02.00.07"

DEFAULT_PREFERENCE = "-1"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "v2.6.37_OMAPPSP_04.02.00.07"
