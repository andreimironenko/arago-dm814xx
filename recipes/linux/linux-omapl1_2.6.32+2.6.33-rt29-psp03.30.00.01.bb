require linux-omapl1.inc

COMPATIBLE_MACHINE = "am181x-evm"

KVER = "2.6.33-rt29"
PSPREL = "03.30.00.01"

BRANCH = "v2.6.33-rt"

SRCREV = "1ac65f4f0aec5738efaf68d9c3b290da2238ceb6"
