require linux-omap3.inc

KVER = "2.6.37-rc7"
PSPREL = "04.02.00.01"

SRCREV = "v2.6.37-rc7_OMAPPSP_04.02.00.01"
