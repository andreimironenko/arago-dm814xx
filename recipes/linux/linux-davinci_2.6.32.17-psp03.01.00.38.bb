require linux-davinci.inc

SRCREV = "4f9428cfefd8b9a56df9ecb1012cd6aeacba670f"

KVER = "2.6.32.17"
PSPREL = "03.01.00.38"

