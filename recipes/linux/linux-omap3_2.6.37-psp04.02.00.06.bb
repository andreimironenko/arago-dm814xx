require linux-omap3.inc

KVER = "2.6.37"
PSPREL = "04.02.00.06"

SRCREV= "v2.6.37_OMAPPSP_04.02.00.06"

