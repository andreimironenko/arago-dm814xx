require u-boot-davinci.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "DEV.DaVinciPSP.03.01.01.39"

UVER = "2010.12-rc2"
PSPREL = "03.01.01.39"

PR = "r0"
