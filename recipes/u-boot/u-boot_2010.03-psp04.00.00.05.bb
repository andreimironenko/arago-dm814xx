require u-boot-omap3.inc

COMPATIBLE_MACHINE = "ti816x"

BRANCH = "ti816x-master"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "v2010.03_TI816XPSP_04.00.00.05"

UVER = "2010.03"
PSPREL = "04.00.00.05"

PR = "r3"
