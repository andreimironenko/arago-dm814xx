require u-boot-omap3.inc

COMPATIBLE_MACHINE = "omap3"

BRANCH = "master"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "v2010.06_OMAPPSP_04.02.00.07"

UVER = "2010.06"
PSPREL = "04.02.00.07"

PR = "r1"
