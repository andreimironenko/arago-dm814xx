BRANCH = "03.21.00.03"

require u-boot-davinci.inc

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "v2010.12_DAVINCIPSP_03.21.00.04"

UVER = "2010.12"
PSPREL = "03.21.00.04"

PR = "r0"
