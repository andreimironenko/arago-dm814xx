require u-boot-omapl1.inc

# use the commit id recommended by PSP for SD/MMC boot support.
SRCREV = "3ef075ec7c7cb1b046719ca495de97bd72e6a5d4"

UVER = "2009.11"
PSPREL = "03.20.00.13"

PR = "r1"
