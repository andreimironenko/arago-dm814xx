require u-boot-omapl1.inc

BRANCH = "am1810"

COMPATIBLE_MACHINE = "am181x-evm"

SRCREV = "e9216316a33f10d631c286d89f62415bb8b1b715"

UVER = "2009.11"
PSPREL = "03.30.00.01"

PR = "r1"
