require u-boot_${PV}.inc

# Use the version of u-boot that saves the environment into NAND as the default
UBOOT_MACHINE = "am335x_evm_config_nand"
