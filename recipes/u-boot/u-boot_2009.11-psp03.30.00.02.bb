require u-boot-omapl1.inc

BRANCH = "am1810"

COMPATIBLE_MACHINE = "am181x-evm"

SRCREV = "v2009.11_DAVINCIPSP_03.30.00.02"

UVER = "2009.11"
PSPREL = "03.30.00.02"

PR = "r1"
