include ti-compat-bluetooth.inc
PR = "r0"
COMPAT_BLUETOOTH_VERSION = "2011-10-30-r4-11"


SRC_URI = "https://gforge.ti.com/gf/download/frsrelease/708/5156/compat-bluetooth-wl12xx-2011-10-30-r4-11.tar.gz"


SRC_URI[md5sum] = "4422782182ab2c06888620f404db51a8"
SRC_URI[sha256sum] = "3fd438a95c416e0b73896a02b77cf893c95c2d4e6d9aa636feea830bd1f24b93"
