MIRRORS_append () {
ftp://.*/.*	http://arago-project.org/files/sources/
https?$://.*/.*	http://arago-project.org/files/sources/
ftp://.*/.*	ftp://128.247.105.176/pub/int-packages/
https?$://.*/.*	ftp://128.247.105.176/pub/int-packages/
}
